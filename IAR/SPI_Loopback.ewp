# IAR project SPI_Loopback.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M453VG6AE Nuvoton M453VG6AE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\Library\CMSIS\Include; ..\Library\StdDriverM451\inc; ..\Library\Device\Nuvoton\M451Series\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SPI_Loopback.bin
  ILINK.IlinkOutputFile: SPI_Loopback.out
  ILINK.IlinkIcfFile: SPI_Loopback.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../Library/Device/Nuvoton/M451Series/Source/IAR/: startup_M451Series.s
    ../Library/Device/Nuvoton/M451Series/Source/: system_M451Series.c
  group Library
    ../Library/StdDriverM451/src/: clk.c crc.c gpio.c i2c.c retarget.c spi.c timer.c uart.c
    C:/Nuvoton/BSP Library/NUC029xAN_Series_BSP_CMSIS_V3.00.005/Library/nuconsole/: NuConsole.c NuConsole.h NuConsole_Config.h
  group User
    ../: main.c
